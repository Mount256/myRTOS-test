# Keil uVision project UCOS-III.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: UCOS-III
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\User;..\User\uC-CPU;..\User\uC-LIB;..\User\uCOS-III\Ports;..\User\uCOS-III\Source
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../User/: app.c
  group μC/OS-III Source
    ../User/uCOS-III/Source/: os_core.c os_cfg_app.c os_task.c os_time.c os_tick.c os_prio.c os_var.c os.h os_cfg.h os_cfg_app.h os_type.h
  group μC/OS-III Ports
    ../User/uCOS-III/Ports/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group μC/CPU
    ../User/uC-CPU/: cpu.h cpu_a.asm cpu_core.c cpu_core.h cpu_def.h cpu_cfg.h
  group μC/LIB
    ../User/uC-LIB/: lib_def.h
  group Doc
    ../Doc/: README.txt
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.1
