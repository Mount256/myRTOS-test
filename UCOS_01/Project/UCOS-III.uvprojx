# Keil uVision project UCOS-III.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: UCOS-III
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\User;..\User\uC-CPU;..\User\uC-LIB;..\User\uCOS-III\Ports;..\User\uCOS-III\Source
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../User/: app.c
  group Doc
    ../Doc/: README.txt
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.1
